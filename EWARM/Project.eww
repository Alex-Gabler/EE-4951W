<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\EE-4951W.ewp</path>
  </project>
  <batchBuild />
</workspace>
